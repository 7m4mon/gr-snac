options:
  parameters:
    author: 7M4MON
    description: Standard GNU Radio CPM/FEC; edit variables and restart.
    generate_options: qt_gui
    id: narrowband_4cpfsk
    output_language: python
    run_options: run
    title: 'Gaussian 4CPFSK: single carrier'
  states: {}

blocks:
- name: symbol_rate
  id: variable
  parameters:
    value: '1312.5'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '32'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: symbol_rate * samples_per_symbol
  states: {}
- name: modulation_index_h
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: gaussian_bt
  id: variable
  parameters:
    value: '0.30'
  states: {}
- name: pulse_length
  id: variable
  parameters:
    value: '4'
  states: {}
- name: channel_spacing
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: seed
  id: variable
  parameters:
    value: '12345'
  states: {}
- name: random_symbols
  id: variable
  parameters:
    value: '262144'
  states: {}
- name: duration_seconds
  id: variable
  parameters:
    value: '60'
  states: {}
- name: iq_path
  id: variable
  parameters:
    value: '''narrowband_4cpfsk.cf32'''
  states: {}
- name: numpy_import
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: window_size
  id: snippet
  parameters:
    section: main_after_init
    code: self.resize(1200, 900)
  states: {}
- name: source_0
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: np.random.default_rng(seed + 0).integers(0, 4, random_symbols, dtype=np.uint8).tolist()
    repeat: 'True'
  states: {}
- name: gray_0
  id: digital_map_bb
  parameters:
    map: '[253, 255, 3, 1]'
  states: {}
- name: cpm_0
  id: digital_cpmmod_bc
  parameters:
    type: analog.cpm.GAUSSIAN
    mod_index: modulation_index_h
    samples_per_symbol: samples_per_symbol
    L: pulse_length
    beta: gaussian_bt
  states: {}
- name: capture_length
  id: blocks_head
  parameters:
    type: complex
    num_items: int(duration_seconds * sample_rate)
  states: {}
- name: throttle
  id: blocks_throttle
  parameters:
    type: complex
    samples_per_second: sample_rate
  states: {}
- name: frequency
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: Spectrum (use mouse zoom for +/-5 kHz)
    fftsize: '8192'
    norm_window: 'True'
    fc: '0'
    bw: sample_rate
    grid: 'True'
    average: '0.05'
    gui_hint: 0,0,1,1
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: Gaussian 4CPFSK
    fftsize: '8192'
    fc: '0'
    bw: sample_rate
    gui_hint: 1,0,1,1
  states: {}
- name: iq_file
  id: blocks_file_sink
  parameters:
    file: iq_path
    type: complex
  states: {}

connections:
- [source_0, '0', gray_0, '0']
- [gray_0, '0', cpm_0, '0']
- [cpm_0, '0', capture_length, '0']
- [capture_length, '0', throttle, '0']
- [throttle, '0', frequency, '0']
- [throttle, '0', waterfall, '0']
- [throttle, '0', iq_file, '0']

metadata:
  file_format: 1
