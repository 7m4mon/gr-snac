options:
  parameters:
    author: 7M4MON
    description: 'Finite file receiver: fixed sample clock, no CFO tracking; metadata supplies audio length.'
    generate_options: qt_gui
    id: receive_snac_4cpfsk
    output_language: python
    run_options: run
    title: 4CPFSK IQ -> SNAC -> WAV
  states: {}

blocks:
- name: capture
  id: variable
  parameters:
    value: rx_support.preview_info(iq_path)
  states: {}
- name: decoder
  id: variable
  parameters:
    value: fec.cc_decoder.make(104, 7, 2, [109, 79], 0, -1, fec.CC_TAILBITING, False)
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: '42000'
  states: {}
- name: acquisition
  id: epy_block
  parameters:
    _source_code: |
      """Finite capture buffer and protocol-specific sync extraction for the GRC."""
      import json
      from pathlib import Path
      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):
          def __init__(self, sample_count=1024, frame_count=1, acquire_fn=None, status_path='', validation_error=''):
              gr.basic_block.__init__(self, name='Finite Capture Sync / 4-level Decisions',
                                      in_sig=[np.float32], out_sig=[np.uint8])
              if validation_error:
                  raise ValueError(validation_error)
              self.sample_count, self.frame_count = int(sample_count), int(frame_count)
              if self.sample_count < 1 or self.frame_count < 1:
                  raise ValueError('Positive finite capture and frame counts required')
              self.acquire_fn, self.status_path = acquire_fn, status_path
              self.buffer = np.empty(self.sample_count, dtype=np.float32)
              self.received = self.offset = 0
              self.bits = None
              self.error = None
              self.status = {}

          def forecast(self, noutput_items, ninputs):
              return [0 if self.bits is not None or self.error is not None else 1]

          def general_work(self, input_items, output_items):
              if self.error is not None:
                  return -1
              if self.bits is None:
                  n = min(len(input_items[0]), self.sample_count-self.received)
                  self.buffer[self.received:self.received+n] = input_items[0][:n]
                  self.received += n
                  self.consume(0, n)
                  if self.received < self.sample_count:
                      return 0
                  try:
                      self.bits, self.status = self.acquire_fn(self.buffer, self.frame_count)
                      self.status.update(error=None, captured_samples=self.received)
                  except Exception as exc:
                      self.error = exc
                      self.status = dict(error=str(exc), captured_samples=self.received)
                  self.buffer = None
                  if self.status_path:
                      Path(self.status_path).write_text(json.dumps(self.status, indent=2)+'\n')
                  if self.error is not None:
                      return -1
              n = min(len(output_items[0]), len(self.bits)-self.offset)
              if n == 0:
                  return -1
              output_items[0][:n] = self.bits[self.offset:self.offset+n]
              self.offset += n
              return n
    acquire_fn: rx_support.acquire
    frame_count: capture['frames']
    sample_count: capture['iq_samples'] + 320
    status_path: wav_path + '.sync.json'
    validation_error: capture['validation_error']
  states: {}
- name: deinterleave
  id: blocks_matrix_interleaver
  parameters:
    cols: '13'
    deint: 'True'
    rows: '16'
    type: byte
  states: {}
- name: demod
  id: analog_quadrature_demod_cf
  parameters:
    gain: 32/(np.pi*0.25)
  states: {}
- name: drain
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: '[0.0]*320'
  states: {}
- name: drain_mux
  id: blocks_stream_mux
  parameters:
    lengths: '[capture[''iq_samples''], 320]'
    type: float
  states: {}
- name: equalizer
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rx_support.equalizer_taps()
    type: fff
  states: {}
- name: fec_decode
  id: fec_extended_decoder
  parameters:
    decoder_list: decoder
    puncpat: '11'
    threadtype: none
  states: {}
- name: imports
  id: import
  parameters:
    imports: |-
      import numpy as np
      from gnuradio import fec
  states: {}
- name: iq_path
  id: parameter
  parameters:
    label: iq_path
    type: str
    value: wav_snac_4cpfsk.cf32
  states: {}
- name: iq_source
  id: blocks_file_source
  parameters:
    file: iq_path
    repeat: 'False'
    type: complex
  states: {}
- name: offset
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: radio_frame
  id: epy_module
  parameters:
    source_code: |
      """Experimental SNAC radio frame v2: information bits and stock GNU Radio framing.

      Custom code only packs 84 payload bits, 8 control bits and CRC-12. FEC, bit
      repacking and sync multiplexing use GNU Radio blocks, just as in the GRC.
      """
      import argparse
      import json
      import operator
      import wave
      from pathlib import Path

      import numpy as np

      PAYLOAD_BITS = 84
      INFORMATION_BITS = 104
      CODED_BITS = 208
      FRAME_SYMBOLS = 112
      POLYNOMIALS = [109, 79]  # GNU Radio bit-mask convention, positive = no inversion.
      INTERLEAVER_ROWS, INTERLEAVER_COLS = 16, 13
      WHITENING_MASK, WHITENING_SEED, WHITENING_LEN = 0x21, 0x1ff, 8
      # GNU Radio inserts feedback at bit index 8: this is a nine-bit register.
      # Experimental fixed word: two occurrences of each dibit; not an acquisition claim.
      SYNC_DIBITS = (0, 3, 1, 0, 2, 1, 3, 2)  # 00 11 01 00 10 01 11 10 = 0x349e


      def wav_transmission_info(filename, repeat_count=5):
          """Validate the same PCM input contract as the existing SNAC WAV example."""
          repeats = operator.index(repeat_count)
          if repeats < 1:
              raise ValueError('repeat_count must be an integer >= 1 (total number of plays)')
          with wave.open(str(filename), 'rb') as wav:
              if wav.getframerate() != 24000 or wav.getnchannels() != 1 or wav.getcomptype() != 'NONE':
                  raise ValueError('Use an uncompressed 24000 Hz mono PCM WAV')
              if wav.getsampwidth() not in (1, 2, 3, 4) or wav.getnframes() < 1:
                  raise ValueError('WAV must contain nonempty 8/16/24/32-bit integer PCM')
              samples = wav.getnframes()
          total = samples*repeats
          return dict(input_path=str(Path(filename).resolve()), wav_samples=samples, repeat_count=repeats,
                      total_audio_samples=total, frame_count=(total+2047)//2048,
                      audio_seconds=total/24000, final_frame_audio_samples=(total-1)%2048+1)


      def checked_bits(bits, size=None):
          values = np.asarray(bits)
          if values.ndim != 1 or not np.all((values == 0) | (values == 1)):
              raise ValueError('Expected a one-dimensional array of bits (0 or 1)')
          if size is not None and len(values) != size:
              raise ValueError(f'Expected {size} bits, got {len(values)}')
          return values.astype(np.uint8)


      def integer_bits(value, width):
          value = operator.index(value)
          if not 0 <= value < (1 << width):
              raise ValueError(f'Value must fit in {width} bits')
          return np.array([(value >> i) & 1 for i in range(width-1, -1, -1)], dtype=np.uint8)


      def crc12(bits):
          """CRC-12/DECT parameters: poly=0x80f, init=0, no reflection/xorout.

          Feed exactly the supplied bits MSB first; there is no byte alignment padding.
          Check value for ASCII '123456789' is 0xf5b. Append register MSB first.
          """
          register = 0
          for bit in checked_bits(bits):
              feedback = ((register >> 11) & 1) ^ int(bit)
              register = (register << 1) & 0xfff
              if feedback:
                  register ^= 0x80f
          return register


      def pack_information(payload, sequence=0, flags=0):
          """Return 104 unpacked bits: payload[84], sequence[6], flags[2], CRC[12]."""
          payload = checked_bits(payload, PAYLOAD_BITS)
          body = np.concatenate([payload, integer_bits(sequence, 6), integer_bits(flags, 2)])
          return np.concatenate([body, integer_bits(crc12(body), 12)])


      def random_information(frame_count, seed=12345, start_sequence=0, flags=0):
          """Finite frame bank; sequence increments modulo 64, seed controls payload only."""
          frame_count = operator.index(frame_count)
          if frame_count < 1:
              raise ValueError('frame_count must be positive')
          integer_bits(start_sequence, 6)
          integer_bits(flags, 2)
          rng = np.random.default_rng(seed)
          payloads = rng.integers(0, 2, (frame_count, PAYLOAD_BITS), dtype=np.uint8)
          return np.concatenate([pack_information(payload, (start_sequence+i) % 64, flags)
                                 for i, payload in enumerate(payloads)])


      def encoder_object():
          from gnuradio import fec
          return fec.cc_encoder_make(INFORMATION_BITS, 7, 2, POLYNOMIALS,
                                     0, fec.CC_TAILBITING, False)


      def make_symbols(information):
          """Stock FEC -> interleave -> whiten -> Repack Bits -> sync mux chain.

          The Head removes any extra sync emitted before the mux sees data EOF.
          No custom FEC, bit-pair mapper or scheduler block is used here.
          """
          from gnuradio import blocks, digital, fec, gr
          information = checked_bits(information)
          if len(information) == 0 or len(information) % INFORMATION_BITS:
              raise ValueError('Information must contain complete 104-bit frames')
          count = len(information)//INFORMATION_BITS
          tb = gr.top_block()
          source = blocks.vector_source_b(information.tolist(), False)
          encoder = fec.extended_encoder(encoder_object(), threading=None, puncpat='11')
          interleaver = blocks.matrix_interleaver(gr.sizeof_char, INTERLEAVER_ROWS, INTERLEAVER_COLS, False)
          whitening = digital.additive_scrambler_bb(WHITENING_MASK, WHITENING_SEED,
              WHITENING_LEN, count=CODED_BITS, bits_per_byte=1, reset_tag_key='')
          pairs = blocks.repack_bits_bb(1, 2, '', False, gr.GR_MSB_FIRST)
          sync = blocks.vector_source_b(SYNC_DIBITS, True)
          mux = blocks.stream_mux(gr.sizeof_char, [8, 104])
          head = blocks.head(gr.sizeof_char, count*FRAME_SYMBOLS)
          sink = blocks.vector_sink_b()
          tb.connect(source, encoder, interleaver, whitening, pairs, (mux, 1))
          tb.connect(sync, (mux, 0))
          tb.connect(mux, head, sink)
          tb.run()
          symbols = np.asarray(sink.data(), dtype=np.uint8)
          if len(symbols) != count*FRAME_SYMBOLS:
              raise RuntimeError(f'Incomplete frame output: {len(symbols)} symbols')
          return symbols


      def format_metadata():
          return dict(format='snac-radio-experimental-v2', payload_bits=84,
                      sequence_bits=6, flags_bits=2, information_bits=104,
                      crc=dict(width=12, poly='0x80f', init=0, refin=False, refout=False,
                               xorout=0, check_123456789='0xf5b', protected_bits=92,
                               bit_order='MSB first, no byte padding'),
                      fec=dict(k=7, rate='1/2', polys=POLYNOMIALS, mode='CC_TAILBITING',
                               padded=False, coded_bits=208),
                      sync_dibits=SYNC_DIBITS, frame_symbols=112, mapping=[-3, -1, 3, 1],
                      interleaver=dict(rows=16, cols=13, order='write rows, read columns', frame_bits=208),
                      scrambler=dict(type='additive XOR', mask='0x21', seed='0x1ff',
                          gnuradio_len=8, register_bits=9, count=208, bits_per_byte=1,
                          reset='before every coded frame', sync_excluded=True))


      def write_capture_metadata(iq_path, frames, seed, sequence, flags, symbol_rate, sps,
                                 h, bt, length, spacing, carriers):
          """Record the exact planned finite capture; completion is checked via file length."""
          record = dict(**format_metadata(), frames=frames, seed=seed,
              carrier_seeds=[seed+i for i in range(carriers)], start_sequence=sequence, flags=flags,
              symbol_rate=symbol_rate, samples_per_symbol=sps, sample_rate=symbol_rate*sps,
              h=h, bt=bt, pulse_length=length, channel_spacing=spacing, carriers=carriers,
              frame_duration_seconds=112/symbol_rate, drain_symbols=length,
              expected_iq_samples=(112*frames+length)*sps,
              expected_dibits_per_carrier=112*frames,
              capture_status='planned; a manually interrupted capture may be shorter')
          Path(str(iq_path)+'.frames.json').write_text(json.dumps(record, indent=2)+'\n')


      def main():
          ap = argparse.ArgumentParser(description=__doc__)
          ap.add_argument('--frames', type=int, default=704)
          ap.add_argument('--seed', type=int, default=12345)
          ap.add_argument('--sequence', type=int, default=0)
          ap.add_argument('--flags', type=int, default=0)
          ap.add_argument('--output', type=Path, default=Path('framed_4cpfsk.dibits'))
          args = ap.parse_args()
          info = random_information(args.frames, args.seed, args.sequence, args.flags)
          symbols = make_symbols(info)
          args.output.parent.mkdir(parents=True, exist_ok=True)
          symbols.tofile(args.output)
          record = dict(**format_metadata(), frames=args.frames, seed=args.seed,
                        start_sequence=args.sequence, flags=args.flags,
                        first_information_bits=''.join(map(str, info[:104].tolist())),
                        first_frame_dibits=symbols[:112].tolist())
          args.output.with_suffix('.frames.json').write_text(json.dumps(record, indent=2)+'\n')
          print(f'{args.frames} frames, {len(symbols)} dibits -> {args.output}')


      if __name__ == '__main__':
          main()
  states: {}
- name: rx_errors
  id: snippet
  parameters:
    code: |-
      self.resize(1100, 700)
      def check_receiver():
          error = self.acquisition.error or self.tokens.error or self.snac_decoder.error
          ready = self.tokens.eos_sent and self.wav_sink.nitems_read(0) == self.capture['audio_samples']
          if error is not None or ready:
              self.stop()
              self.wait()
              result = rx_support.finish_receiver(self)
              self.setWindowTitle('Receive complete: ' + self.wav_path if result['complete'] else 'Receive failed: ' + str(error))
              print(result, flush=True)
              self._rx_timer.stop()
      self._rx_timer = Qt.QTimer(self)
      self._rx_timer.timeout.connect(check_receiver)
      self._rx_timer.start(100)
    section: main_after_init
  states: {}
- name: rx_support
  id: epy_module
  parameters:
    source_code: |
      """Finite-file receiver parameters, Gaussian equalizer design and sync acquisition.

      No transmitted payload, dibit file or RNG state is used for acquisition.
      The first receiver intentionally assumes the transmitter sample clock and no CFO.
      """
      import json
      from pathlib import Path
      import numpy as np


      def capture_info(iq_path):
          meta = json.loads(Path(str(iq_path)+'.frames.json').read_text())
          if (meta.get('format') != 'snac-radio-experimental-v2' or meta.get('carriers') != 1
                  or meta.get('samples_per_symbol') != 32 or meta.get('h') != .25
                  or meta.get('bt') != .3 or meta.get('pulse_length') != 4
                  or meta.get('sample_rate') != 42000):
              raise ValueError('Receiver requires single-carrier v2, 42 kHz, SPS32, h=.25, BT=.3, L4')
          samples = Path(iq_path).stat().st_size//8
          if Path(iq_path).stat().st_size % 8 or samples < meta['expected_iq_samples']:
              raise ValueError('Incomplete complex64 IQ capture')
          # Extra prefix/suffix samples are allowed for acquisition experiments.
          audio_samples = meta['audio']['total_audio_samples']
          if audio_samples < 1 or (audio_samples+2047)//2048 != meta['frames']:
              raise ValueError('Inconsistent finite audio length')
          return dict(iq_samples=samples, frames=meta['frames'], audio_samples=audio_samples,
                      start_sequence=meta['start_sequence'], context_frames=meta.get('context_frames', 2), validation_error='')


      def preview_info(iq_path):
          # GRC must remain editable before the first TX capture exists. The acquisition
          # block rejects this placeholder at runtime, before processing any samples.
          try:
              return capture_info(iq_path)
          except (OSError, ValueError, KeyError, TypeError) as exc:
              return dict(iq_samples=3712, frames=1, audio_samples=2048, start_sequence=0,
                          context_frames=2, validation_error=f'Invalid IQ/metadata: {exc}')


      def equalizer_taps():
          """9 symbol-spaced inverse FIR, implemented by stock FIR Filter in GRC.

          Sampled Gaussian frequency pulse is a five-tap ISI channel. Least squares
          approximates its inverse with a four-symbol delay. No received data is fitted.
          """
          from gnuradio import analog, digital
          pulse = np.asarray(digital.cpmmod_bc(analog.cpm.GAUSSIAN, .25, 32, 4, .3).taps())*32
          channel = np.r_[pulse[::32], 0.0]
          convolution = np.zeros((len(channel)+8, 9))
          for i in range(9):
              convolution[i:i+len(channel), i] = channel
          target = np.zeros(len(convolution))
          target[6] = 1
          inverse = np.linalg.lstsq(convolution, target, rcond=None)[0]
          taps = np.zeros(257)
          taps[::32] = inverse
          return taps.tolist()


      def finish_receiver(tb):
          """Call after the graph has stopped; close WAV and report actual completion."""
          tb.wav_sink.close()
          errors = [str(e) for e in (tb.acquisition.error, tb.tokens.error, tb.snac_decoder.error) if e is not None]
          saved = int(tb.wav_sink.nitems_read(0))
          complete = (not errors and tb.tokens.eos_sent and tb.snac_decoder.ended
                      and saved == tb.capture['audio_samples'])
          record = dict(complete=complete, errors=errors, saved_audio_samples=saved,
                        expected_audio_samples=tb.capture['audio_samples'],
                        accepted_frames=tb.tokens.frames, crc_failures=tb.tokens.crc_failures,
                        sync=tb.acquisition.status, audio_length_source='TX sidecar JSON, not an on-air field')
          Path(tb.wav_path+'.rx.json').write_text(json.dumps(record, indent=2)+'\n')
          return record


      def acquire(samples, frame_count):
          """Try 32 sampling phases and exact sync matches at 112-symbol spacing.

          All expected sync words must agree. Rank candidates by distance to the four
          legal levels, then recover the data bits. CRC/FEC run in downstream blocks.
          """
          sync = np.array([0, 3, 1, 0, 2, 1, 3, 2], dtype=np.uint8)
          level_to_dibit = np.array([0, 1, 3, 2], dtype=np.uint8)
          best = None
          for phase in range(32):
              values = np.asarray(samples[phase::32])
              indices = np.clip(np.floor((values+4)/2), 0, 3).astype(np.int32)
              dibits = level_to_dibit[indices]
              if len(dibits) < frame_count*112:
                  continue
              windows = np.lib.stride_tricks.sliding_window_view(dibits, 8)
              hits = np.flatnonzero(np.all(windows == sync, axis=1))
              hit_set = set(hits.tolist())
              for start in hits:
                  end = start+frame_count*112
                  if end > len(dibits) or not all(start+112*i in hit_set for i in range(frame_count)):
                      continue
                  error = float(np.mean((values[start:end]-(2*indices[start:end]-3))**2))
                  if best is None or error < best[0]:
                      best = error, phase, int(start), dibits[start:end].copy()
          if best is None:
              raise ValueError('No complete sync chain: truncated capture, clock/CFO error or excessive noise')
          error, phase, start, dibits = best
          data = dibits.reshape(-1, 112)[:, 8:].reshape(-1)
          bits = np.stack([data >> 1, data & 1], axis=1).reshape(-1).astype(np.uint8)
          return bits, dict(sampling_phase=phase, first_sync_symbol=start,
                            first_sync_sample=start*32+phase, sync_frames=frame_count,
                            level_mse=error)
  states: {}
- name: scale
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: snac_decoder
  id: snac_decoder
  parameters:
    context_frames: '2'
    device: cpu
    model: hubertsiuzdak/snac_24khz
    verbose: 'False'
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    bw: sample_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 0,0,1,1
    name: '''Received IQ'''
    type: complex
  states: {}
- name: to_float
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: tokens
  id: epy_block
  parameters:
    _source_code: |
      """CRC/sequence checking and inverse token packing; embedded in receiver GRC."""
      import json
      from pathlib import Path
      import numpy as np
      import pmt
      from gnuradio import gr
      from gnuradio.snac.messages import pack
      from gr_snac_core.frames import FRAME_MODE


      class blk(gr.sync_block):
          def __init__(self, total_samples=2048, start_sequence=0, crc_fn=None, status_path=''):
              gr.sync_block.__init__(self, name='CRC / Sequence -> SNAC Tokens',
                                     in_sig=[(np.uint8, 104)], out_sig=None)
              self.total_samples = int(total_samples)
              self.expected_frames = (self.total_samples+2047)//2048
              self.start_sequence, self.crc_fn, self.status_path = start_sequence, crc_fn, status_path
              self.frames = self.audio_samples = self.crc_failures = 0
              self.error = None
              self.eos_sent = False
              self.message_port_register_out(pmt.intern('codes'))

          def _meta(self):
              return dict(codec='snac', model='hubertsiuzdak/snac_24khz', sample_rate=24000,
                          num_levels=3, chunk_index=self.frames, stream_mode=FRAME_MODE)

          def _status(self):
              if self.status_path:
                  Path(self.status_path).write_text(json.dumps(dict(
                      accepted_frames=self.frames, expected_frames=self.expected_frames,
                      audio_samples=self.audio_samples, crc_failures=self.crc_failures,
                      eos_sent=self.eos_sent, error=str(self.error) if self.error else None,
                      note='Token-stage status; waveform completion requires decoder and WAV-length checks'), indent=2)+'\n')

          def work(self, input_items, output_items):
              if self.error is not None or self.eos_sent:
                  return -1
              consumed = 0
              try:
                  for bits in input_items[0]:
                      consumed += 1
                      if self.crc_fn(bits) != 0:
                          self.crc_failures += 1
                          raise ValueError(f'CRC failure at frame {self.frames}; audio aborted (no concealment)')
                      sequence = int(np.dot(bits[84:90], 2**np.arange(5, -1, -1)))
                      if sequence != (self.start_sequence+self.frames)%64:
                          raise ValueError(f'Sequence discontinuity at frame {self.frames}')
                      values = bits[:84].reshape(7, 12).dot(2**np.arange(11, -1, -1)).astype(np.uint16)
                      n = min(2048, self.total_samples-self.audio_samples)
                      meta = self._meta()
                      meta.update(audio_samples=n, encoded_samples=2048, crop_start=0,
                                  chunk_duration_ms=n/24000*1000)
                      self.message_port_pub(pmt.intern('codes'), pack(meta, [values[:1], values[1:3], values[3:]]))
                      self.frames += 1
                      self.audio_samples += n
                      if self.frames == self.expected_frames:
                          meta = self._meta()
                          meta['eos'] = True
                          self.message_port_pub(pmt.intern('codes'), pack(meta))
                          self.eos_sent = True
                          self._status()
                          break
              except Exception as exc:
                  self.error = exc
                  self._status()
              return consumed

          def stop(self):
              self._status()
              return True
    crc_fn: radio_frame.crc12
    start_sequence: capture['start_sequence']
    status_path: wav_path + '.frames.json'
    total_samples: capture['audio_samples']
  states: {}
- name: vectors
  id: blocks_stream_to_vector
  parameters:
    num_items: '104'
    type: byte
  states: {}
- name: wav_path
  id: parameter
  parameters:
    label: wav_path
    type: str
    value: received_snac.wav
  states: {}
- name: wav_sink
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: wav_path
    format: FORMAT_WAV
    samp_rate: '24000'
  states: {}
- name: whitening
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '208'
    len: '8'
    mask: '0x21'
    reset_tag_key: ''
    seed: '0x1ff'
  states: {}

connections:
- [acquisition, '0', whitening, '0']
- [deinterleave, '0', to_float, '0']
- [demod, '0', drain_mux, '0']
- [drain, '0', drain_mux, '1']
- [drain_mux, '0', equalizer, '0']
- [equalizer, '0', acquisition, '0']
- [fec_decode, '0', vectors, '0']
- [iq_source, '0', demod, '0']
- [iq_source, '0', spectrum, '0']
- [offset, '0', fec_decode, '0']
- [scale, '0', offset, '0']
- [snac_decoder, '0', wav_sink, '0']
- [to_float, '0', scale, '0']
- [tokens, codes, snac_decoder, codes]
- [vectors, '0', tokens, '0']
- [whitening, '0', deinterleave, '0']

metadata:
  file_format: 1
