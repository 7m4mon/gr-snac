options:
  parameters:
    author: 7M4MON
    description: Finite repeated WAV through the SNAC encoder and stock radio PHY; IQ output only.
    generate_options: qt_gui
    id: wav_snac_4cpfsk
    output_language: python
    run_options: run
    title: WAV -> SNAC -> framed 4CPFSK
  states: {}

blocks:
- name: symbol_rate
  id: variable
  parameters:
    value: '1312.5'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '32'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: symbol_rate * samples_per_symbol
  states: {}
- name: modulation_index_h
  id: variable
  parameters:
    value: '0.25'
  states: {}
- name: gaussian_bt
  id: variable
  parameters:
    value: '0.30'
  states: {}
- name: pulse_length
  id: variable
  parameters:
    value: '4'
  states: {}
- name: channel_spacing
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: iq_path
  id: variable
  parameters:
    value: '''wav_snac_4cpfsk.cf32'''
  states: {}
- name: frame_count
  id: variable
  parameters:
    value: wav_info['frame_count']
  states: {}
- name: start_sequence
  id: variable
  parameters:
    value: '0'
  states: {}
- name: frame_flags
  id: variable
  parameters:
    value: '0'
  states: {}
- name: dibit_path
  id: variable
  parameters:
    value: '''wav_snac_4cpfsk.dibits'''
  states: {}
- name: input_path
  id: parameter
  parameters:
    label: WAV input (24 kHz mono PCM)
    type: str
    value: ../VOICEACTRESS100_001_001.wav
  states: {}
- name: repeat_count
  id: parameter
  parameters:
    label: Total WAV plays
    type: intx
    value: '5'
  states: {}
- name: wav_info
  id: variable
  parameters:
    value: radio_frame.wav_transmission_info(input_path, repeat_count)
  states: {}
- name: total_samples
  id: variable
  parameters:
    value: wav_info['total_audio_samples']
  states: {}
- name: numpy_import
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: radio_frame
  id: epy_module
  parameters:
    source_code: |
      """Experimental SNAC radio frame v2: information bits and stock GNU Radio framing.

      Custom code only packs 84 payload bits, 8 control bits and CRC-12. FEC, bit
      repacking and sync multiplexing use GNU Radio blocks, just as in the GRC.
      """
      import argparse
      import json
      import operator
      import wave
      from pathlib import Path

      import numpy as np

      PAYLOAD_BITS = 84
      INFORMATION_BITS = 104
      CODED_BITS = 208
      FRAME_SYMBOLS = 112
      POLYNOMIALS = [109, 79]  # GNU Radio bit-mask convention, positive = no inversion.
      INTERLEAVER_ROWS, INTERLEAVER_COLS = 16, 13
      WHITENING_MASK, WHITENING_SEED, WHITENING_LEN = 0x21, 0x1ff, 8
      # GNU Radio inserts feedback at bit index 8: this is a nine-bit register.
      # Experimental fixed word: two occurrences of each dibit; not an acquisition claim.
      SYNC_DIBITS = (0, 3, 1, 0, 2, 1, 3, 2)  # 00 11 01 00 10 01 11 10 = 0x349e


      def wav_transmission_info(filename, repeat_count=5):
          """Validate the same PCM input contract as the existing SNAC WAV example."""
          repeats = operator.index(repeat_count)
          if repeats < 1:
              raise ValueError('repeat_count must be an integer >= 1 (total number of plays)')
          with wave.open(str(filename), 'rb') as wav:
              if wav.getframerate() != 24000 or wav.getnchannels() != 1 or wav.getcomptype() != 'NONE':
                  raise ValueError('Use an uncompressed 24000 Hz mono PCM WAV')
              if wav.getsampwidth() not in (1, 2, 3, 4) or wav.getnframes() < 1:
                  raise ValueError('WAV must contain nonempty 8/16/24/32-bit integer PCM')
              samples = wav.getnframes()
          total = samples*repeats
          return dict(input_path=str(Path(filename).resolve()), wav_samples=samples, repeat_count=repeats,
                      total_audio_samples=total, frame_count=(total+2047)//2048,
                      audio_seconds=total/24000, final_frame_audio_samples=(total-1)%2048+1)


      def checked_bits(bits, size=None):
          values = np.asarray(bits)
          if values.ndim != 1 or not np.all((values == 0) | (values == 1)):
              raise ValueError('Expected a one-dimensional array of bits (0 or 1)')
          if size is not None and len(values) != size:
              raise ValueError(f'Expected {size} bits, got {len(values)}')
          return values.astype(np.uint8)


      def integer_bits(value, width):
          value = operator.index(value)
          if not 0 <= value < (1 << width):
              raise ValueError(f'Value must fit in {width} bits')
          return np.array([(value >> i) & 1 for i in range(width-1, -1, -1)], dtype=np.uint8)


      def crc12(bits):
          """CRC-12/DECT parameters: poly=0x80f, init=0, no reflection/xorout.

          Feed exactly the supplied bits MSB first; there is no byte alignment padding.
          Check value for ASCII '123456789' is 0xf5b. Append register MSB first.
          """
          register = 0
          for bit in checked_bits(bits):
              feedback = ((register >> 11) & 1) ^ int(bit)
              register = (register << 1) & 0xfff
              if feedback:
                  register ^= 0x80f
          return register


      def pack_information(payload, sequence=0, flags=0):
          """Return 104 unpacked bits: payload[84], sequence[6], flags[2], CRC[12]."""
          payload = checked_bits(payload, PAYLOAD_BITS)
          body = np.concatenate([payload, integer_bits(sequence, 6), integer_bits(flags, 2)])
          return np.concatenate([body, integer_bits(crc12(body), 12)])


      def random_information(frame_count, seed=12345, start_sequence=0, flags=0):
          """Finite frame bank; sequence increments modulo 64, seed controls payload only."""
          frame_count = operator.index(frame_count)
          if frame_count < 1:
              raise ValueError('frame_count must be positive')
          integer_bits(start_sequence, 6)
          integer_bits(flags, 2)
          rng = np.random.default_rng(seed)
          payloads = rng.integers(0, 2, (frame_count, PAYLOAD_BITS), dtype=np.uint8)
          return np.concatenate([pack_information(payload, (start_sequence+i) % 64, flags)
                                 for i, payload in enumerate(payloads)])


      def encoder_object():
          from gnuradio import fec
          return fec.cc_encoder_make(INFORMATION_BITS, 7, 2, POLYNOMIALS,
                                     0, fec.CC_TAILBITING, False)


      def make_symbols(information):
          """Stock FEC -> interleave -> whiten -> Repack Bits -> sync mux chain.

          The Head removes any extra sync emitted before the mux sees data EOF.
          No custom FEC, bit-pair mapper or scheduler block is used here.
          """
          from gnuradio import blocks, digital, fec, gr
          information = checked_bits(information)
          if len(information) == 0 or len(information) % INFORMATION_BITS:
              raise ValueError('Information must contain complete 104-bit frames')
          count = len(information)//INFORMATION_BITS
          tb = gr.top_block()
          source = blocks.vector_source_b(information.tolist(), False)
          encoder = fec.extended_encoder(encoder_object(), threading=None, puncpat='11')
          interleaver = blocks.matrix_interleaver(gr.sizeof_char, INTERLEAVER_ROWS, INTERLEAVER_COLS, False)
          whitening = digital.additive_scrambler_bb(WHITENING_MASK, WHITENING_SEED,
              WHITENING_LEN, count=CODED_BITS, bits_per_byte=1, reset_tag_key='')
          pairs = blocks.repack_bits_bb(1, 2, '', False, gr.GR_MSB_FIRST)
          sync = blocks.vector_source_b(SYNC_DIBITS, True)
          mux = blocks.stream_mux(gr.sizeof_char, [8, 104])
          head = blocks.head(gr.sizeof_char, count*FRAME_SYMBOLS)
          sink = blocks.vector_sink_b()
          tb.connect(source, encoder, interleaver, whitening, pairs, (mux, 1))
          tb.connect(sync, (mux, 0))
          tb.connect(mux, head, sink)
          tb.run()
          symbols = np.asarray(sink.data(), dtype=np.uint8)
          if len(symbols) != count*FRAME_SYMBOLS:
              raise RuntimeError(f'Incomplete frame output: {len(symbols)} symbols')
          return symbols


      def format_metadata():
          return dict(format='snac-radio-experimental-v2', payload_bits=84,
                      sequence_bits=6, flags_bits=2, information_bits=104,
                      crc=dict(width=12, poly='0x80f', init=0, refin=False, refout=False,
                               xorout=0, check_123456789='0xf5b', protected_bits=92,
                               bit_order='MSB first, no byte padding'),
                      fec=dict(k=7, rate='1/2', polys=POLYNOMIALS, mode='CC_TAILBITING',
                               padded=False, coded_bits=208),
                      sync_dibits=SYNC_DIBITS, frame_symbols=112, mapping=[-3, -1, 3, 1],
                      interleaver=dict(rows=16, cols=13, order='write rows, read columns', frame_bits=208),
                      scrambler=dict(type='additive XOR', mask='0x21', seed='0x1ff',
                          gnuradio_len=8, register_bits=9, count=208, bits_per_byte=1,
                          reset='before every coded frame', sync_excluded=True))


      def write_capture_metadata(iq_path, frames, seed, sequence, flags, symbol_rate, sps,
                                 h, bt, length, spacing, carriers):
          """Record the exact planned finite capture; completion is checked via file length."""
          record = dict(**format_metadata(), frames=frames, seed=seed,
              carrier_seeds=[seed+i for i in range(carriers)], start_sequence=sequence, flags=flags,
              symbol_rate=symbol_rate, samples_per_symbol=sps, sample_rate=symbol_rate*sps,
              h=h, bt=bt, pulse_length=length, channel_spacing=spacing, carriers=carriers,
              frame_duration_seconds=112/symbol_rate, drain_symbols=length,
              expected_iq_samples=(112*frames+length)*sps,
              expected_dibits_per_carrier=112*frames,
              capture_status='planned; a manually interrupted capture may be shorter')
          Path(str(iq_path)+'.frames.json').write_text(json.dumps(record, indent=2)+'\n')


      def main():
          ap = argparse.ArgumentParser(description=__doc__)
          ap.add_argument('--frames', type=int, default=704)
          ap.add_argument('--seed', type=int, default=12345)
          ap.add_argument('--sequence', type=int, default=0)
          ap.add_argument('--flags', type=int, default=0)
          ap.add_argument('--output', type=Path, default=Path('framed_4cpfsk.dibits'))
          args = ap.parse_args()
          info = random_information(args.frames, args.seed, args.sequence, args.flags)
          symbols = make_symbols(info)
          args.output.parent.mkdir(parents=True, exist_ok=True)
          symbols.tofile(args.output)
          record = dict(**format_metadata(), frames=args.frames, seed=args.seed,
                        start_sequence=args.sequence, flags=args.flags,
                        first_information_bits=''.join(map(str, info[:104].tolist())),
                        first_frame_dibits=symbols[:112].tolist())
          args.output.with_suffix('.frames.json').write_text(json.dumps(record, indent=2)+'\n')
          print(f'{args.frames} frames, {len(symbols)} dibits -> {args.output}')


      if __name__ == '__main__':
          main()
  states: {}
- name: capture_metadata
  id: snippet
  parameters:
    section: main_after_init
    priority: '1'
    code: |-
      radio_frame.write_capture_metadata(self.iq_path, self.frame_count, 0, self.start_sequence, self.frame_flags, self.symbol_rate, self.samples_per_symbol, self.modulation_index_h, self.gaussian_bt, self.pulse_length, self.channel_spacing, 1)
      from pathlib import Path
      import json
      meta_path = Path(self.iq_path + '.frames.json')
      record = json.loads(meta_path.read_text())
      record.pop('seed', None)
      record.pop('carrier_seeds', None)
      record.update(source='WAV -> SNAC encoder', audio=self.wav_info, codec_model=self.snac_encoder.codec.model_id, context_frames=self.snac_encoder.context)
      meta_path.write_text(json.dumps(record, indent=2) + '\n')
  states: {}
- name: frame_errors
  id: snippet
  parameters:
    section: main_after_init
    priority: '2'
    code: |-
      def check_frame_error():
          if self.token_frames.error is not None:
              self.setWindowTitle('SNAC framing error: ' + str(self.token_frames.error))
              self.stop()
              self._frame_error_timer.stop()
      self._frame_error_timer = Qt.QTimer(self)
      self._frame_error_timer.timeout.connect(check_frame_error)
      self._frame_error_timer.start(100)
  states: {}
- name: window_size
  id: snippet
  parameters:
    section: main_after_init
    code: self.resize(1200, 900)
  states: {}
- name: wav_source
  id: blocks_wavfile_source
  parameters:
    file: input_path
    repeat: 'True'
  states: {}
- name: audio_length
  id: blocks_head
  parameters:
    type: float
    num_items: total_samples
  states: {}
- name: snac_encoder
  id: snac_encoder
  parameters:
    model: hubertsiuzdak/snac_24khz
    device: cpu
    context_frames: '2'
    verbose: 'False'
    total_samples: total_samples
  states: {}
- name: token_frames
  id: epy_block
  parameters:
    _source_code: |
      """Message-only SNAC token packer, embedded in the WAV transmitter GRC.

      No custom stream scheduler or FEC: emit 104-bit PDUs to standard PDU to Tagged
      Stream. frame_packer is supplied by the GRC's embedded radio_frame module.
      """
      import json
      import logging
      import threading
      from pathlib import Path

      import numpy as np
      import pmt
      from gnuradio import gr
      from gnuradio.snac.messages import unpack
      from gr_snac_core.frames import FRAME_MODE


      class blk(gr.basic_block):
          """SNAC 1/2/4 tokens -> 84 payload bits -> 104 information bits."""

          def __init__(self, total_samples=2048, start_sequence=0, flags=0,
                       frame_packer=None, status_path=''):
              gr.basic_block.__init__(self, name='SNAC Tokens to Radio PDU', in_sig=None, out_sig=None)
              if type(total_samples) is not int or total_samples < 1:
                  raise ValueError('total_samples must be a positive integer')
              if not 0 <= start_sequence < 64 or not 0 <= flags < 4:
                  raise ValueError('Invalid sequence or flags')
              self.total_samples = total_samples
              self.expected_frames = (total_samples+2047)//2048
              self.start_sequence, self.flags = start_sequence, flags
              self.frame_packer = frame_packer
              self.status_path = status_path
              self.frames = self.audio_samples = 0
              self.eos_received = False
              self.error = None
              self._lock = threading.Lock()
              self.message_port_register_in(pmt.intern('codes'))
              self.message_port_register_out(pmt.intern('pdus'))
              self.set_msg_handler(pmt.intern('codes'), self._handle)

          def _write_status(self):
              if self.status_path:
                  record = dict(source='SNAC encoder messages', payload_bit_order='level0, level1, level2; each token MSB first',
                      frames=self.frames, expected_frames=self.expected_frames, audio_samples=self.audio_samples,
                      expected_audio_samples=self.total_samples, eos_received=self.eos_received,
                      error=str(self.error) if self.error else None,
                      note='Encoder/PDU status only; check IQ length to confirm complete waveform capture')
                  Path(self.status_path).write_text(json.dumps(record, indent=2)+'\n')

          def _handle(self, message):
              with self._lock:
                  if self.error is not None:
                      return
                  try:
                      if self.eos_received:
                          raise ValueError('SNAC message after EOS')
                      meta, levels = unpack(message, 'hubertsiuzdak/snac_24khz')
                      if meta.get('stream_mode') != FRAME_MODE or meta['chunk_index'] != self.frames:
                          raise ValueError('Missing, reordered or unsupported SNAC frame')
                      if levels is None:
                          if self.frames != self.expected_frames or self.audio_samples != self.total_samples:
                              raise ValueError('Premature SNAC EOS')
                          self.eos_received = True
                          self._write_status()
                          return
                      expected_samples = min(2048, self.total_samples-self.audio_samples)
                      if self.frames >= self.expected_frames or meta['audio_samples'] != expected_samples:
                          raise ValueError('SNAC frame sample count does not match repeated WAV length')
                      if tuple(map(len, levels)) != (1, 2, 4):
                          raise ValueError('Expected 1/2/4 SNAC tokens')
                      tokens = np.concatenate(levels).astype(np.uint16)
                      payload = ((tokens[:, None] >> np.arange(11, -1, -1)) & 1).astype(np.uint8).reshape(-1)
                      if self.frame_packer is None:
                          raise ValueError('frame_packer must be supplied by embedded radio_frame module')
                      bits = self.frame_packer(payload, (self.start_sequence+self.frames)%64, self.flags)
                      self.message_port_pub(pmt.intern('pdus'), pmt.cons(pmt.PMT_NIL,
                          pmt.init_u8vector(104, bits.tolist())))
                      self.frames += 1
                      self.audio_samples += meta['audio_samples']
                  except Exception as exc:
                      self.error = exc
                      logging.getLogger(__name__).exception('SNAC token framing failed')
                      self._write_status()

          def stop(self):
              with self._lock:
                  self._write_status()
              return True
    total_samples: total_samples
    start_sequence: start_sequence
    flags: frame_flags
    frame_packer: radio_frame.pack_information
    status_path: iq_path + '.audio.json'
  states: {}
- name: source_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    type: byte
    tag: packet_len
  states: {}
- name: encoder_definition_0
  id: variable_cc_encoder_def
  parameters:
    ndim: '0'
    framebits: '104'
    k: '7'
    rate: '2'
    polys: '[109, 79]'
    state_start: '0'
    mode: fec.CC_TAILBITING
    padding: 'False'
  states: {}
- name: fec_0
  id: fec_extended_encoder
  parameters:
    encoder_list: encoder_definition_0
    threadtype: none
    puncpat: '''11'''
  states: {}
- name: interleaver_0
  id: blocks_matrix_interleaver
  parameters:
    type: byte
    rows: '16'
    cols: '13'
    deint: 'False'
  states: {}
- name: whitening_0
  id: digital_additive_scrambler_bb
  parameters:
    mask: '0x21'
    seed: '0x1ff'
    len: '8'
    count: '208'
    bits_per_byte: '1'
    reset_tag_key: ''''''
  states: {}
- name: pairs_0
  id: blocks_repack_bits_bb
  parameters:
    k: '1'
    l: '2'
    len_tag_key: ''''''
    endianness: gr.GR_MSB_FIRST
  states: {}
- name: sync_0
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: radio_frame.SYNC_DIBITS
    repeat: 'True'
  states: {}
- name: frame_mux_0
  id: blocks_stream_mux
  parameters:
    type: byte
    lengths: '[8, 104]'
  states: {}
- name: frame_limit_0
  id: blocks_head
  parameters:
    type: byte
    num_items: frame_count * 112
  states: {}
- name: dibit_file_0
  id: blocks_file_sink
  parameters:
    file: dibit_path
    type: byte
  states: {}
- name: gray_0
  id: digital_map_bb
  parameters:
    map: '[253, 255, 3, 1]'
  states: {}
- name: cpm_0
  id: digital_cpmmod_bc
  parameters:
    type: analog.cpm.GAUSSIAN
    mod_index: modulation_index_h
    samples_per_symbol: samples_per_symbol
    L: pulse_length
    beta: gaussian_bt
  states: {}
- name: drain_zero_0
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: '[0]'
    repeat: 'True'
  states: {}
- name: drain_mux_0
  id: blocks_stream_mux
  parameters:
    type: byte
    lengths: '[frame_count * 112, pulse_length]'
  states: {}
- name: drain_limit_0
  id: blocks_head
  parameters:
    type: byte
    num_items: frame_count * 112 + pulse_length
  states: {}
- name: capture_length
  id: blocks_head
  parameters:
    type: complex
    num_items: (frame_count * 112 + pulse_length) * samples_per_symbol
  states: {}
- name: throttle
  id: blocks_throttle
  parameters:
    type: complex
    samples_per_second: sample_rate
  states: {}
- name: frequency
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: Spectrum (use mouse zoom for +/-5 kHz)
    fftsize: '8192'
    norm_window: 'True'
    fc: '0'
    bw: sample_rate
    grid: 'True'
    average: '0.05'
    gui_hint: 0,0,1,1
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    type: complex
    name: Gaussian 4CPFSK
    fftsize: '8192'
    fc: '0'
    bw: sample_rate
    gui_hint: 1,0,1,1
  states: {}
- name: iq_file
  id: blocks_file_sink
  parameters:
    file: iq_path
    type: complex
  states: {}

connections:
- [wav_source, '0', audio_length, '0']
- [audio_length, '0', snac_encoder, '0']
- [snac_encoder, codes, token_frames, codes]
- [token_frames, pdus, source_0, pdus]
- [source_0, '0', fec_0, '0']
- [fec_0, '0', interleaver_0, '0']
- [interleaver_0, '0', whitening_0, '0']
- [whitening_0, '0', pairs_0, '0']
- [pairs_0, '0', frame_mux_0, '1']
- [sync_0, '0', frame_mux_0, '0']
- [frame_mux_0, '0', frame_limit_0, '0']
- [frame_limit_0, '0', dibit_file_0, '0']
- [frame_limit_0, '0', gray_0, '0']
- [gray_0, '0', drain_mux_0, '0']
- [drain_zero_0, '0', drain_mux_0, '1']
- [drain_mux_0, '0', drain_limit_0, '0']
- [drain_limit_0, '0', cpm_0, '0']
- [cpm_0, '0', capture_length, '0']
- [capture_length, '0', throttle, '0']
- [throttle, '0', frequency, '0']
- [throttle, '0', waterfall, '0']
- [throttle, '0', iq_file, '0']

metadata:
  file_format: 1
