options:
  parameters:
    generate_options: no_gui
    id: snac_loopback
    output_language: python
    run_options: run
    title: SNAC 24k WAV Loopback
  states: {}

blocks:
- name: input_path
  id: variable
  parameters:
    value: '''VOICEACTRESS100_001_001.wav'''
  states: {}
- name: output_path
  id: variable
  parameters:
    value: '''reconstructed1.wav'''
  states: {}
- name: sample_count
  id: variable
  parameters:
    value: wave.open(input_path, 'rb').getnframes()
  states: {}
- name: token_path
  id: variable
  parameters:
    value: '''encoded.snac'''
  states: {}
- name: decoder
  id: snac_decoder
  parameters:
    context_frames: '2'
    device: cpu
    model: hubertsiuzdak/snac_24khz
    verbose: 'True'
  states: {}
- name: encoder
  id: snac_encoder
  parameters:
    context_frames: '2'
    device: cpu
    model: hubertsiuzdak/snac_24khz
    total_samples: sample_count
    verbose: 'True'
  states: {}
- name: sink
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: output_path
    format: FORMAT_WAV
    samp_rate: '24000'
  states: {}
- name: source
  id: blocks_wavfile_source
  parameters:
    file: input_path
    repeat: 'False'
  states: {}
- name: token_file
  id: snac_token_file
  parameters:
    filename: token_path
    model: hubertsiuzdak/snac_24khz
  states: {}
- name: wav_import
  id: import
  parameters:
    imports: import wave
  states: {}

connections:
- [decoder, '0', sink, '0']
- [encoder, codes, token_file, codes]
- [source, '0', encoder, '0']
- [token_file, codes, decoder, codes]

metadata:
  file_format: 1
