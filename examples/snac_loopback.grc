options:
  parameters:
    id: snac_loopback
    title: SNAC 24k WAV Loopback
    generate_options: no_gui
    output_language: python
    run_options: run
  states: {}

blocks:
- name: wav_import
  id: import
  parameters:
    imports: import wave
  states: {}
- name: input_path
  id: variable
  parameters:
    value: '''input.wav'''
  states: {}
- name: output_path
  id: variable
  parameters:
    value: '''reconstructed.wav'''
  states: {}
- name: sample_count
  id: variable
  parameters:
    value: wave.open(input_path, 'rb').getnframes()
  states: {}
- name: source
  id: blocks_wavfile_source
  parameters:
    file: input_path
    repeat: 'False'
  states: {}
- name: encoder
  id: snac_encoder
  parameters:
    model: hubertsiuzdak/snac_24khz
    device: cpu
    chunk_ms: '1000'
    verbose: 'True'
    total_samples: sample_count
  states: {}
- name: decoder
  id: snac_decoder
  parameters:
    model: hubertsiuzdak/snac_24khz
    device: cpu
    verbose: 'True'
  states: {}
- name: sink
  id: blocks_wavfile_sink
  parameters:
    file: output_path
    samp_rate: '24000'
    format: FORMAT_WAV
    bits_per_sample1: FORMAT_PCM_16
  states: {}

connections:
- [source, '0', encoder, '0']
- [encoder, codes, decoder, codes]
- [decoder, '0', sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
